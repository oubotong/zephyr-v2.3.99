## samples/net/sockets/coap_client/build/Kconfig/Kconfig.soc.arch
```kconfig
osource "/home/dafran/test/zephyr/soc/$(ARCH)/Kconfig"
osource "/home/dafran/test/zephyr/soc/$(ARCH)/*/Kconfig"
```
